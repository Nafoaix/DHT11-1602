# Keil uVision project 温湿度监测.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 温湿度监测 +hex
  c flags: Optimize=1 SizeSpeed=1
  group Source Group 1
    ./: MAIN.c 1602.c 1602.h DHT11.c DHT11.h
